## boards/shields/proto/Kconfig.deconfig
```kconfig
if SHIELD_PROTO

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "proto"

endif
```
